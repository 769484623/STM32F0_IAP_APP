# Keil uVision project Template.uvprojx, settings and files
target TJ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\USR;.\LIB\inc;.\CORE;..\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USR
    ./USR/: main.c stm32f0xx_it.c system_stm32f0xx.c
    ./: BSP.c FlashOP.c
  group LIB
    ./LIB/src/: stm32f0xx_gpio.c stm32f0xx_spi.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_flash.c
  group CORE
    ./CORE/: startup_stm32f0xx.s
