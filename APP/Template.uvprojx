# Keil uVision project Template.uvprojx, settings and files
target TJ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\USR;.\LIB\inc;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000c00 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c0 size 0x1f40
  group USR
    ./USR/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group LIB
    ./LIB/src/: stm32f0xx_gpio.c stm32f0xx_spi.c stm32f0xx_rcc.c stm32f0xx_syscfg.c
  group CORE
    ./CORE/: startup_stm32f0xx.s
